# IAR project carte_deplacement.ewp, settings and files
configuration carte_deplacement (ARM, debug)
  General.OGChipSelectEditMenu: STM32F722RE ST STM32F722RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F722xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\ENCODERS_MouadhJeridi; ..\Drivers\OLED_MouadhJeridi; ..\Drivers\STEPPERS_MouadhJeridi; ..\App\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: carte_deplacement.hex
  ILINK.IlinkOutputFile: carte_deplacement.out
  ILINK.IlinkIcfFile: stm32f722xx_ITCM_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Inc
    ../App/Inc/: robot_app.h robot_board.h robot_configs.h robot_display.h robot_events.h robot_i2c.h robot_port.h robot_settings.h robot_status.h
  group App/Src
    ../App/Src/: robot_app.c robot_board.c robot_display.c robot_events.c robot_i2c.c robot_port_baremetal.c robot_settings.c robot_status.c
  group Application/EWARM
    ./: startup_stm32f722xx.s
  group Application/User/Core
    ../Core/Src/: main.c motion.c robot_protocol.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/ENCODERS_MouadhJeridi
    ../Drivers/ENCODERS_MouadhJeridi/: ENCODERS_MouadhJeridi.c ENCODERS_MouadhJeridi.h
  group Drivers/OLED_MouadhJeridi
    ../Drivers/OLED_MouadhJeridi/: _ansi.h OLED_MouadhJeridi.c OLED_MouadhJeridi.h ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h
  group Drivers/STEPPERS_MouadhJeridi
    ../Drivers/STEPPERS_MouadhJeridi/: STEPPERS_MouadhJeridi.c STEPPERS_MouadhJeridi.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
